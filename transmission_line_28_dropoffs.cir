* C:\LTSpiceTransmissionLines\LTSpice\sim\main\tranmission_line.asc
O2 N026 N052 Out OutRef LossyTL
rf N052 0 100k
C1 N026 0 {Cdrp}
O1 N025 N051 N026 N052 LossyTL
rf1 N051 0 100k
C2 N025 0 {Cdrp}
O3 N024 N050 N025 N051 LossyTL
rf2 N050 0 100k
C3 N024 0 {Cdrp}
O4 N023 N049 N024 N050 LossyTL
rf3 N049 0 100k
C4 N023 0 {Cdrp}
O5 N022 N048 N023 N049 LossyTL
rf4 N048 0 100k
C5 N022 0 {Cdrp}
O6 N021 N047 N022 N048 LossyTL
rf5 N047 0 100k
C6 N021 0 {Cdrp}
O7 N020 N046 N021 N047 LossyTL
rf6 N046 0 100k
C7 N020 0 {Cdrp}
O8 N019 N045 N020 N046 LossyTL
rf7 N045 0 100k
C8 N019 0 {Cdrp}
O9 N018 N044 N019 N045 LossyTL
rf8 N044 0 100k
C9 N018 0 {Cdrp}
O10 N017 N043 N018 N044 LossyTL
rf9 N043 0 100k
C10 N017 0 {Cdrp}
O11 N016 N042 N017 N043 LossyTL
rf10 N042 0 100k
C11 N016 0 {Cdrp}
O12 N015 N041 N016 N042 LossyTL
rf11 N041 0 100k
C12 N015 0 {Cdrp}
O13 N014 N040 N015 N041 LossyTL
rf12 N040 0 100k
C13 N014 0 {Cdrp}
O14 N013 N039 N014 N040 LossyTL
rf13 N039 0 100k
C14 N013 0 {Cdrp}
O15 N012 N038 N013 N039 LossyTL
rf14 N038 0 100k
C15 N012 0 {Cdrp}
O16 N011 N037 N012 N038 LossyTL
rf15 N037 0 100k
C16 N011 0 {Cdrp}
O17 N010 N036 N011 N037 LossyTL
rf16 N036 0 100k
C17 N010 0 {Cdrp}
O18 N009 N035 N010 N036 LossyTL
rf17 N035 0 100k
C18 N009 0 {Cdrp}
rf18 N034 0 100k
C19 N008 0 {Cdrp}
O20 N007 N033 N008 N034 LossyTL
rf19 N033 0 100k
C20 N007 0 {Cdrp}
O21 N006 N032 N007 N033 LossyTL
rf20 N032 0 100k
C21 N006 0 {Cdrp}
O22 N005 N031 N006 N032 LossyTL
rf21 N031 0 100k
C22 N005 0 {Cdrp}
O23 N004 N030 N005 N031 LossyTL
rf22 N030 0 100k
C23 N004 0 {Cdrp}
O24 N003 N029 N004 N030 LossyTL
RoutRef OutRef 0 100k
O19 N008 N034 N009 N035 LossyTL
rf24 N029 0 100k
C24 N003 0 {Cdrp}
O25 N002 N028 N003 N029 LossyTL
rf25 N028 0 100k
C25 N002 0 {Cdrp}
O26 N001 N027 N002 N028 LossyTL
rf26 N027 0 100k
C26 N001 0 {Cdrp}
O27 InPulse InRefPulse N001 N027 LossyTL
R16 InPulse InRefPulse {Rterm}
R17 InRefPulse 0 100k
V2 InPulse InRefPulse PULSE(0 1 0 2n 2n 16n) AC 1 Rser=0
R2 Out OutRef {Rterm}
.model LossyTL  LTRA(len=Lenline R=Rline L=Lline C=Cline)
.tran 0 100n
;ac oct 50 10k 1000Meg
;step param Rline 0.02 2 0.2
;step param Lline 0.079n 7.9n 0.79n
;step param Cline 0.22p 22p 2.2p
;step param Cdrp 1p 5p 1p
;step param Lenline 1.0 10.0 1.0
.param  Cdrp 3.0p  Rterm =sqrt(Lline/Cline) Lenline=4.0 Rline=20.m Lline=6.4n  Cline=11.p
.save V(Out) V(N001) V(N027) V(N014) V(N040) V(N026)  V(N052) V(InPulse
.backanno
.end
